# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\App;..\SYSTEM\delay;..\Libraries\AIR32F10xLib\inc;..\Libraries\CMSIS\Include;..\Libraries\AIR32F10xLib\lib\cryptlib;..\Libraries\AIR32F10xLib\src;..\Libraries\STARTUP\arm;..\App\Lib;..\App\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../App/: air32f10x_it.c app.c main.c air32f10x_conf.h air32f10x_it.h app.h
  group App/Lib
    ../App/Lib/: uart.c uart.h gpio.c gpio.h time.c time.h rcc.c rcc.h r_spi.c r_spi.h r_i2c.c r_i2c.h dac.c dac.h adc.c adc.h
  group App/Hardware
    ../App/Hardware/: oled.c oled.h oledfont.c oledfont.h CH224K.c CH224K.h key.h key.c esp8266.c esp8266.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../Libraries/STARTUP/arm/: startup_air32f10x.s
  group FWLib
    ../Libraries/AIR32F10xLib/src/: misc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_spi.c air32f10x_usart.c air32f10x_tim.c air32f10x_adc.c air32f10x_rtc.c air32f10x_dac.c air32f10x_dma.c
